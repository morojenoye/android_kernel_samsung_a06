## drivers/power/supply/mediatek/charger/charge_pump/Kconfig
```kconfig
config CHARGER_CP_PPS
	bool "CHARGER_CP_PPS"
	default n
	help
	  Say Y to enable support for charge pump pps.
```
